## boards/shields/turtle_keyb/Kconfig.defconfig
```kconfig
if SHIELD_TURTLE_KEYB

config ZMK_KEYBOARD_NAME
    default "Turtle Keyboard"
   
endif
```
